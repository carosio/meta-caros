require erlang-couchbeam.inc
SRCREV="d34ebb6ea97260c3dd775d796bff67c87b2717de"

PR = "${INC_PR}.1"
