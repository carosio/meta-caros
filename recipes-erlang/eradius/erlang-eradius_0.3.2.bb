require erlang-eradius.inc

SRCREV="896adbd2eeb8c94b3124dd68698a06cacee14580"
PR = "${INC_PR}.1"

SRC_URI = "git://git@git.tpip.net/eradius.git;protocol=ssh"
