require erlang-flower.inc

SRC_URI = "git://git@git.tpip.net/flower.git;protocol=ssh;branch=of12_exp"
SRCREV = "e1b3f92fa68e579974b23b0be406577fb677e722"

PR = "r1"
