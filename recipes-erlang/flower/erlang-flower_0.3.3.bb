require erlang-flower.inc

SRC_URI = "git://git@git.tpip.net/flower.git;protocol=ssh;branch=of12_exp"
SRCREV = "63bd8fcff9ff9ac06af43d0ba652b41c9c414bfd"

PR = "r1"
