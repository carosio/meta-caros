require erlang-flower.inc

SRC_URI = "git://git@git.tpip.net/flower.git;protocol=ssh;branch=of12_exp"
SRCREV = "d49a6864b1a5df1257300162e2948db5e072d69b"

PR = "2"
