require erlang-flower.inc

SRC_URI = "git://git@git.tpip.net/flower.git;protocol=ssh;branch=of12_exp"
SRCREV = "9089e13cea7456f9b83d795d47b50f9b31fc13db"

PR = "r1"
