require erlang-flower.inc

SRC_URI = "git://git@git.tpip.net/flower.git;protocol=ssh;branch=of12_exp"
SRCREV = "330c3d242cd3880eaf85ba13bc1fdc7f3900c83f"

PR = "0.0"
