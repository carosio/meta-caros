require erlang-flower.inc

SRC_URI = "git://git@git.tpip.net/flower.git;protocol=ssh;branch=of12_exp"
SRCREV = "9af04790209efd494516d78a9259d216cbeab018"

PR = "r2"
