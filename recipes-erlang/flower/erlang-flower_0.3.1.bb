require erlang-flower.inc

SRC_URI = "git://git@git.tpip.net/flower.git;protocol=ssh;branch=of12_exp"
SRCREV = "bcbf73964c1e03eb48dedf1c6c3762c07d273c26"

PR = "r2"
