PR:="${PR}.2"
HOME_URL="caros.io"
BUG_REPORT_URL="support@travelping.com"

OS_RELEASE_FIELDS += "HOME_URL BUG_REPORT_URL"
PRETTY_NAME = '${DISTRO_NAME} ${VERSION}'
