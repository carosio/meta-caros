PACKAGES =+ "util-linux-unshare"

FILES_util-linux-unshare = "${bindir}/unshare"

PACKAGES =+ "util-linux-setterm"
FILES_util-linux-setterm = "${bindir}/setterm"
