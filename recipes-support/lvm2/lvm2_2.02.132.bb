require lvm2.inc

SRC_URI[md5sum] = "80af5af726949bbbb2aceb15b24b7d20"
SRC_URI[sha256sum] = "413aa09cd5babb2e01b0209ed4be514645fa8b492664f57f384352a7f58f8829"
