require jansson.inc

SRC_URI[md5sum] = "00dd7b55c01c74cac59df398208b92ed"
SRC_URI[sha256sum] = "98fa4dd0e0dff679e5085490f5fafa38bdda088f4553348c0281832d24afe541"
