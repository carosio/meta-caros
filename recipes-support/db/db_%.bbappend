PR := "${PR}.1"

EXTRA_OECONF += "--enable-compat185"
