PR := "${PR}.1"

RDEPENDS_${PN}_append = " kernel-module-openvswitch "
