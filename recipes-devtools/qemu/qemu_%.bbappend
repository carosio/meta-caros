EXTRA_OECONF += "--disable-glusterfs"
