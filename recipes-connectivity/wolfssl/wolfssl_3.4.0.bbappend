EXTRA_OECONF = "--enable-dtls \
	        --enable-ipv6 \
		--enable-aesgcm \
		--enable-aesccm \
		--enable-aesni \
		--enable-poly1305 \
		--enable-ecc \
		--enable-ecc25519 \
		--enable-chacha \
		--enable-supportedcurves \
		--enable-dh \
		--enable-psk \
		--disable-des3 \
		--disable-arc4 \
		"
