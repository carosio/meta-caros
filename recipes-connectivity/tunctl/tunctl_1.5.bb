require tunctl.inc

LICENSE = "GPLv2+"
LIC_FILES_CHKSUM = "file://tunctl.c;endline=3;md5=a5fb6d53d8d52c08cfa4a7437731465e"

SRC_URI[md5sum] = "fdbedc263b3e85bb0e087cd567414607"
SRC_URI[sha256sum] = "aa2a6c4cc6bfacb11e0d9f62334a6638a0d435475c61230116f00b6af8b14fff"
