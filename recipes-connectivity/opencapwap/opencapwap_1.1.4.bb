require opencapwap.inc

SRCREV = "98106086da9c8f15043e6050be37945543a173c5"
PR = "${INC_PR}.2"
