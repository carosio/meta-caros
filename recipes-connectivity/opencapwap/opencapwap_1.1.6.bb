require opencapwap.inc

SRCREV = "57ec09f4f269b62d910534d3c3e74169006a6c23"
PR = "${INC_PR}.0"
