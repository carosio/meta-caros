require opencapwap.inc

SRCREV = "beb21307e2da09a58d7e37820ee206ccdeb0b57e"
PR = "${INC_PR}.3"
