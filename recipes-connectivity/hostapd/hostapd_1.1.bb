require hostapd.inc

LICENSE = "GPLv2 | BSD"
LIC_FILES_CHKSUM = "file://README;md5=9bee93996fecdb70f807baceb29d84b9"

SRC_URI[md5sum] = "e3ace8306d066ab2d24b4c9f668e2dd7"
SRC_URI[sha256sum] = "d1ec8d2550f4f59d7611d8de68a61936cd3645fffdd2854c5b2bc758ece3b66c"
