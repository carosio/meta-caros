FEATURE_PACKAGES_erlang = "task-core-erlang"
FEATURE_PACKAGES_erlang-sdk = "task-core-erlang-sdk"

CAROS_IMAGE_FEATURES = "package-management"
CAROS_IMAGE_SDK_FEATURES = "package-management"
