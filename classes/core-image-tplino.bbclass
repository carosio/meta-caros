FEATURE_PACKAGES_erlang = "task-core-erlang"
FEATURE_PACKAGES_erlang-sdk = "task-core-erlang-sdk"

TPLINO_IMAGE_FEATURES = "package-management"
TPLINO_IMAGE_SDK_FEATURES = "package-management"
