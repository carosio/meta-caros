# TODO: add header files to our glusterfs package(s)
# (disable glusterfs until then)
EXTRA_OECONF += " --without-glusterfs "
