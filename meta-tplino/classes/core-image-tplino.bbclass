PACKAGE_GROUP_erlang = "task-core-erlang"
PACKAGE_GROUP_erlang-sdk = "task-core-erlang-sdk"

TPLINO_IMAGE_FEATURES = "package-management"
TPLINO_IMAGE_SDK_FEATURES = "package-management"
IMAGE_INASTALL_append = " bind "
