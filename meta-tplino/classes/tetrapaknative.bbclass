PATH_prepend = "${STAGING_BINDIR_NATIVE}/tetrapak-native:"
DEPENDS += "tetrapak-native"
OECMAKE_TETRAPAKNATIVE_DIR = "${STAGING_BINDIR_NATIVE}/tetrapak-native"

INHERIT +="erlangnative"
