require opencapwap.inc

SRCREV = "8ea7368335e800603b9d87d1fb08243c63e3cad8"
PR = "${INC_PR}.0"
