CFLAGS += "-fno-stack-protector"