require erlang-tetrapak-yang.inc
SRCREV="11807257864533e19b6409b5dc05bd8911a96900"

PR = "${INC_PR}.1"
