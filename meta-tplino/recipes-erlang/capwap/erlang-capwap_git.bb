require erlang-capwap.inc

SRC_URI = "git://git@git.tpip.net/capwap.git;protocol=ssh;branch=capwap_flow_exp"
SRCREV = "AUTOINC"

PV = "0.1+git${SRCPV}"
PR = "r0"
