require erlang-enit.inc

LIC_FILES_CHKSUM = "file://src/enit.erl;md5=295820f85c70198bc701a249df3d51e4"

SRCREV = "d73bb0566491a00c9b0bf6c39c137bdb5e4ebd8d"
