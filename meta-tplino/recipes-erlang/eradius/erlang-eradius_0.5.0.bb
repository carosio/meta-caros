require erlang-eradius.inc

SRCREV="811fee0fddd2b22f50719424e0907fc9a0255ad8"
PR = "${INC_PR}.1"

SRC_URI = "git://git@git.tpip.net/eradius.git;protocol=ssh"
