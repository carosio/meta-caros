require erlang-eradius.inc

SRCREV="b87bc8a15cc2fcedbc5d68d77fbbd9c6685d438e"
PR = "r1"

SRC_URI = "git://git@git.tpip.net/eradius.git;protocol=ssh"
