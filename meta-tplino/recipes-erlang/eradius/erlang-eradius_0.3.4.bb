require erlang-eradius.inc

SRCREV="121fe46d4c1a6109f96b6142bbb4449ffe08e58f"
PR="r1"

SRC_URI = "git://git@git.tpip.net/eradius.git;protocol=ssh"
