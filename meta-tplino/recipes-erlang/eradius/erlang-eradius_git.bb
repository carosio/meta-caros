require erlang-eradius.inc

SRCREV="AUTOINC"
PV = "git${SRCPV}"
PR = "r0"

SRC_URI = "git://git@git.tpip.net/eradius.git;protocol=ssh"
