require erlang-eradius.inc

SRCREV="${AUTOREV}"
PV = "0.2.0-${PR}-${SRCPV}"
PR = "r1"

SRC_URI = "git://git@git.tpip.net/eradius.git;protocol=ssh"
