require erlang-dike.inc
SRCREV = "2d1a067819cfb817a96f1f22d07ccb99e76a4af5"

PR = "${INC_PR}.0"
