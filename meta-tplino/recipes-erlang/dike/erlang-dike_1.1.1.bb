require erlang-dike.inc
SRCREV = "a9fa6b2bad80fd669548537717fb49afa3657e19"

PR = "${INC_PR}.1"
