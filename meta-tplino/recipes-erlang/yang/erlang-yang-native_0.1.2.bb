require erlang-yang-native.inc
SRCREV = "ada55793b8e34ad9e771d3a02ba7dba6c9441242"

PR = "${INC_PR}.3"
