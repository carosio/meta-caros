require erlang-yang-native.inc
SRCREV = "3635baebccfea37db481d1653aeeaf45306bb246"

PR = "${INC_PR}.1"
