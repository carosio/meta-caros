require erlang-yang.inc
SRCREV = "7a7319dee7ab1e23a498cff5c126b13b15225e30"

PR = "${INC_PR}.2"
