require erlang-hello.inc
SRCREV = "a256b29763777339900a64021b4dbf09c8ff0dc0"

PR = "${INC_PR}.1"
