require erlang-hello.inc
SRCREV = "39827053bd7be451c69062e1946c2a18a9f98706"

PR = "${INC_PR}.1"
