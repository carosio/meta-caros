SRC_URI[md5sum] = "1c5ee419d4278569db1fca46981918a4"
SRC_URI[sha256sum] = "c075ed390dddc99dfb4804f220214cb5e8eb7c0882694a36b05f6aaa883629d7"

require ethtool.inc
