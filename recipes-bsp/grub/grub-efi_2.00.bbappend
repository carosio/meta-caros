CFLAGS_native += "-fno-stack-protector"
